# Keil uVision project NK1092C_H750.uvprojx, settings and files
target NK1092C_H750 (ARM-ADS)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: NK1092C_H750 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,USE_USB_FS
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Src\Gd\inc;..\Src\Measure;..\Src\QSPI;..\Src\ADC;..\Src\KEY;..\Src\LED;..\Src\LCD;..\Src\ST7789;..\Src\flash;..\Src\usart;..\Src\delay;..\Src\SDMMC;..\Src\SDRAM;..\Src\ICON;..\Src\RTC;..\Src\FATFS\exfuns;..\Src\FATFS\source;..\Src\MALLOC;..\Src\MPU;..\Src\PICTURE;..\Src\STMFLASH;..\Src\USB\STM32_USB_Device_Library\Class\MSC\Inc;..\Src\USB\STM32_USB_Device_Library\Core\Inc;..\Src\USB\USB_APP;..\Src\TIMER
  asm include: ..\\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User
    ../Src/: main.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c
    ../Src/task/: task_default.c task_ircamera.c task_lcd.c
    ../Src/flash/: W25QXX.c
    ../Src/QSPI/: qspi.c sys.c
    ../Src/ADC/: adc.c
    ../Src/KEY/: key.c
    ../Src/LED/: led.c
    ../Src/LCD/: lcd.c
    ../Src/delay/: delay.c
    ../Src/ST7789/: st7789.c fonts.c
    ../Src/usart/: usart.c
    ../Src/ICON/: icon.c
    ../Src/RTC/: rtc.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_pcd.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group UserLib
    ../Src/Gd/src/: Shutter.c SPI.c TempProcess.c Varible.c
  group Lib
    ../Src/Gd/: Sensor.lib
    ../Src/Gd/inc/: Sensor.h
    ../Src/Measure/: MeasureInterface.h Measure.lib
  group SDCard
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_delayblock.c
    ../Src/SDMMC/: sdmmc_sdcard.c
    ../Src/SDRAM/: sdram.c
  group FATFS
    ../Src/FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../Src/FATFS/exfuns/: exfuns.c fattester.c
  group MALLOC
    ../Src/MALLOC/: malloc.c
  group MPU
    ../Src/MPU/: mpu.c
  group PICTURE
    ../Src/PICTURE/: bmp.c
  group STMFLASH
    ../Src/STMFLASH/: stmflash.c
  group USB_DEVICE
    ../Src/USB/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_CORE
    ../Src/USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group USB_APP
    ../Src/USB/USB_APP/: usbd_conf.c usbd_desc.c usbd_storage.c
  group TIMER
    ../Src/TIMER/: timer.c
software components: CMSIS:CORE 4.1.0
